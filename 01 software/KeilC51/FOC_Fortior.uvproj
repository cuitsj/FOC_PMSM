# Keil uVision project FOC_Fortior.uvproj, settings and files
target FU68XX_FOC (MCS-51)
  device: FU68XX Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: FOC_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Library\FU68xx_Hardware_Driver\Include;..\User\Include
  link misc: REMOVEUNUSED
  group Apllication
    ../User/Source/Application/: main.c Interrupt.c AddFunction.c
    ../User/Include/: Customer.h Parameter.h
  group Function
    ../User/Source/Function/: FocControl.c FocControlFunction.c OLED.c
  group Hardware
    ../User/Source/Hardware/: AMPInit.c DriverInit.c EXTIInit.c SPIInit.c SystemInit.c TimerInit.c ADCInit.c CMPInit.c GPIOInit.c FocSpiInit.c MDUInit.c PIInit.c UARTInit.c
  group FU68XX_Hardware_Driver
    ../Library/FU68xx_Hardware_Driver/Source/: PosiCheck.LIB
  group Document
    ../Document/: ReadMe.txt
